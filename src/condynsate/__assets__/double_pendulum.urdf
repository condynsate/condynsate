Commit message: added double pen

File: src/condynsate/__assets__/double_pendulum.urdf (robot description, URDF)
Before this commit: robot double_pendulum, 5 links, 4 joints
Links:
- link mass_1: mass 1 -> 2
- link mass_2: mass 1 -> 2
