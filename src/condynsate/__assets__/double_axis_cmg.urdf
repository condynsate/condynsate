Commit message: proj updates

File: src/condynsate/__assets__/double_axis_cmg.urdf (robot description, URDF)
Before this commit: robot gyro, 5 links, 4 joints
Links:
- removed link Base
Joints:
- removed joint Base_to_A
